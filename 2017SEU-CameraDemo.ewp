# IAR project 2017SEU-CameraDemo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512xxx10 Freescale MK60DN512xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: MK60D10
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: Libraries\Camera\inc; Libraries\Core; Libraries\Device; Libraries\Driver\inc; User
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: 2017SEU-CameraDemo.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    User/: main.c
  group Device
    Libraries/Device/IAR-ARM/: startup_MK60D10.s
    Libraries/Device/: system_MK60D10.c
  group Driver
    Libraries/Driver/src/: common.c dma.c ftm.c gpio.c lptmr.c pit.c sd.c spi.c systick.c uart.c
  group User
    User/: camera.c encoder.c isr.c oled.c pid.c sccbext.c
